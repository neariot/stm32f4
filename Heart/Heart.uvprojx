# Keil uVision project Heart.uvprojx, settings and files
target Heart (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Heart
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: .\CMSIS\Include;.\STM32F4xx_StdPeriph_Driver\inc;.\STM32F4-Discovery;.\CMSIS\ST\STM32F4xx\Include;..\Heart;.\TM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c timer.c usart.c
  group startup
    ./CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group discovery
    ./STM32F4-Discovery/: stm32f4_discovery.c
  group TM
    ./TM/: tm_stm32f4_gpio.c tm_stm32f4_adc.c
  group StdPeriph
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
